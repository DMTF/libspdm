/**
 *  Copyright Notice:
 *  Copyright 2023-2026 DMTF. All rights reserved.
 *  License: BSD 3-Clause License. For full text see link: https://github.com/DMTF/libspdm/blob/main/LICENSE.md
 **/

#include "internal/libspdm_crypt_lib.h"
#include "internal/libspdm_common_lib.h"
#include "internal/libspdm_fips_lib.h"

#if LIBSPDM_FIPS_MODE

#if (LIBSPDM_ECDSA_SUPPORT) && (LIBSPDM_SHA2_SUPPORT)
/* Test vector (key, message, nonce and signature) from the NIST CAVP:
 * ECDSA SigGen.txt, [P-256,SHA-256/SHA-384/SHA-512], first record.
 * https://csrc.nist.gov/projects/cryptographic-algorithm-validation-program/digital-signatures
 * Exactly one of SHA-256/SHA-384/SHA-512 is required for the ECDSA FIPS self-test to run;
 * the strongest one enabled at build time is used.
 */
#if LIBSPDM_SHA512_SUPPORT
/*hardcode random for ecdsa*/
static int libspdm_hardcode_random_number_ecdsa(void *rng_state, unsigned char *output, size_t len)
{
    /*Random number*/
    const uint8_t random[] = {
        0x91, 0x06, 0x19, 0x21, 0x70, 0xcc, 0xb3, 0xc6,
        0x46, 0x84, 0xd4, 0x82, 0x87, 0xbb, 0x81, 0xbb,
        0xed, 0x51, 0xb4, 0x0d, 0x50, 0x34, 0x62, 0xc9,
        0x00, 0xe5, 0xc7, 0xaa, 0xe4, 0x3e, 0x38, 0x0a
    };
    libspdm_copy_mem(output, len, random, sizeof(random));

    return 0;
}
#elif LIBSPDM_SHA384_SUPPORT
/*hardcode random for ecdsa*/
static int libspdm_hardcode_random_number_ecdsa(void *rng_state, unsigned char *output, size_t len)
{
    /*Random number*/
    const uint8_t random[] = {
        0x99, 0x80, 0xb9, 0xcd, 0xfc, 0xef, 0x3a, 0xb8,
        0xe2, 0x19, 0xb9, 0x82, 0x7e, 0xd6, 0xaf, 0xdd,
        0x4d, 0xbf, 0x20, 0xbd, 0x92, 0x7e, 0x9c, 0xd0,
        0x1f, 0x15, 0x76, 0x27, 0x03, 0x48, 0x70, 0x07
    };
    libspdm_copy_mem(output, len, random, sizeof(random));

    return 0;
}
#elif LIBSPDM_SHA256_SUPPORT
/*hardcode random for ecdsa*/
static int libspdm_hardcode_random_number_ecdsa(void *rng_state, unsigned char *output, size_t len)
{
    /*Random number*/
    const uint8_t random[] = {
        0x94, 0xa1, 0xbb, 0xb1, 0x4b, 0x90, 0x6a, 0x61,
        0xa2, 0x80, 0xf2, 0x45, 0xf9, 0xe9, 0x3c, 0x7f,
        0x3b, 0x4a, 0x62, 0x47, 0x82, 0x4f, 0x5d, 0x33,
        0xb9, 0x67, 0x07, 0x87, 0x64, 0x2a, 0x68, 0xde
    };
    libspdm_copy_mem(output, len, random, sizeof(random));

    return 0;
}
#endif /* LIBSPDM_SHA512_SUPPORT */
#endif /* (LIBSPDM_ECDSA_SUPPORT) && (LIBSPDM_SHA2_SUPPORT) */

void libspdm_fips_selftest_ecdsa(void *fips_selftest_context)
{
#if (LIBSPDM_ECDSA_SUPPORT) && (LIBSPDM_SHA2_SUPPORT)
    bool result = true;

    libspdm_fips_selftest_context_t *context = fips_selftest_context;
    LIBSPDM_ASSERT(fips_selftest_context != NULL);

    /* any test fail cause the FIPS fail*/
    if (context->tested_algo != context->self_test_result) {
        return;
    }

    /* check if run before.*/
    if ((context->tested_algo & LIBSPDM_FIPS_SELF_TEST_ECDSA) != 0) {
        return;
    }

    uint8_t signature[32 * 2];
    size_t sig_size;
    void *ec_context;
    size_t hash_nid;

    sig_size = sizeof(signature);
    libspdm_zero_mem(signature, sig_size);

#if LIBSPDM_SHA512_SUPPORT
    hash_nid = LIBSPDM_CRYPTO_NID_SHA512;

    /* The message to sign. */
    const uint8_t message[] = {
        0x6c, 0x85, 0x72, 0xb6, 0xa3, 0xa4, 0xa9, 0xe8,
        0xe0, 0x3d, 0xbe, 0xed, 0x99, 0x33, 0x4d, 0x41,
        0x66, 0x1b, 0x8a, 0x84, 0x17, 0x07, 0x4f, 0x33,
        0x5a, 0xb1, 0x84, 0x5f, 0x6c, 0xc8, 0x52, 0xad,
        0xb8, 0xc0, 0x1d, 0x98, 0x20, 0xfc, 0xf8, 0xe1,
        0x06, 0x99, 0xcc, 0x82, 0x7a, 0x8f, 0xbd, 0xca,
        0x2c, 0xbd, 0x46, 0xcc, 0x66, 0xe4, 0xe6, 0xb7,
        0xba, 0x41, 0xec, 0x3e, 0xfa, 0x73, 0x35, 0x87,
        0xe4, 0xa3, 0x0e, 0xc5, 0x52, 0xcd, 0x8d, 0xda,
        0xb8, 0x16, 0x3e, 0x14, 0x8e, 0x50, 0xf4, 0xd0,
        0x90, 0x78, 0x28, 0x97, 0xf3, 0xdd, 0xac, 0x84,
        0xa4, 0x1e, 0x1f, 0xcf, 0xe8, 0xc5, 0x6b, 0x61,
        0x52, 0xc0, 0x09, 0x7b, 0x0d, 0x63, 0x4b, 0x41,
        0x01, 0x14, 0x71, 0xff, 0xd0, 0x04, 0xf4, 0x3e,
        0xb4, 0xaa, 0xfc, 0x03, 0x81, 0x97, 0xec, 0x6b,
        0xae, 0x2b, 0x44, 0x70, 0xe8, 0x69, 0xbd, 0xed
    };

    /* Private Key */
    const uint8_t priv_key[] = {
        0x9d, 0xd0, 0xd3, 0xa3, 0xd5, 0x14, 0xc2, 0xa8,
        0xad, 0xb1, 0x62, 0xb8, 0x1e, 0x3a, 0xdf, 0xba,
        0x32, 0x99, 0x30, 0x9f, 0x7d, 0x20, 0x18, 0xf6,
        0x07, 0xbd, 0xb1, 0x5b, 0x1a, 0x25, 0xf4, 0x99
    };

    /* Public Key */
    const uint8_t public_key[] = {
        0x6b, 0x73, 0x8d, 0xe3, 0x39, 0x8b, 0x6a, 0xc5,
        0x7b, 0x95, 0x91, 0xf9, 0xd7, 0x98, 0x5d, 0xd4,
        0xf3, 0x21, 0x37, 0xad, 0x34, 0x60, 0xdc, 0xf8,
        0x97, 0x0c, 0x13, 0x90, 0xcb, 0x9e, 0xaf, 0x8d,
        0x83, 0xbc, 0x61, 0xe2, 0x6d, 0x2b, 0xbb, 0xd3,
        0xcf, 0x2d, 0x2a, 0xb4, 0x45, 0xa2, 0xbc, 0x4a,
        0xb5, 0xdd, 0xe4, 0x1f, 0x4a, 0x13, 0x07, 0x8f,
        0xd1, 0xd3, 0xcc, 0x36, 0xab, 0x59, 0x6d, 0x57
    };

    /* Expected signature*/
    const uint8_t expected_signature[] = {
        0x27, 0x5f, 0xa7, 0x60, 0x87, 0x8b, 0x4d, 0xc0,
        0x5e, 0x9d, 0x15, 0x7f, 0xed, 0xfd, 0x8e, 0x9b,
        0x1c, 0x9c, 0x86, 0x12, 0x22, 0xa7, 0x12, 0x74,
        0x8c, 0xb4, 0xb7, 0x75, 0x4c, 0x04, 0x3f, 0xb1,
        0x69, 0x9d, 0x90, 0x6b, 0xb8, 0x43, 0x5a, 0x05,
        0x34, 0x5a, 0xf3, 0xb3, 0x7e, 0x3b, 0x35, 0x77,
        0x86, 0x93, 0x9e, 0x94, 0xca, 0xae, 0x25, 0x78,
        0x52, 0xf0, 0x50, 0x3a, 0xdb, 0x1e, 0x0f, 0x7e
    };
#elif LIBSPDM_SHA384_SUPPORT
    hash_nid = LIBSPDM_CRYPTO_NID_SHA384;

    /* The message to sign. */
    const uint8_t message[] = {
        0xe0, 0xb8, 0x59, 0x6b, 0x37, 0x5f, 0x33, 0x06,
        0xbb, 0xc6, 0xe7, 0x7a, 0x0b, 0x42, 0xf7, 0x46,
        0x9d, 0x7e, 0x83, 0x63, 0x59, 0x90, 0xe7, 0x4a,
        0xa6, 0xd7, 0x13, 0x59, 0x4a, 0x3a, 0x24, 0x49,
        0x8f, 0xef, 0xf5, 0x00, 0x67, 0x90, 0x74, 0x2d,
        0x9c, 0x2e, 0x9b, 0x47, 0xd7, 0x14, 0xbe, 0xe9,
        0x32, 0x43, 0x5d, 0xb7, 0x47, 0xc6, 0xe7, 0x33,
        0xe3, 0xd8, 0xde, 0x41, 0xf2, 0xf9, 0x13, 0x11,
        0xf2, 0xe9, 0xfd, 0x8e, 0x02, 0x56, 0x51, 0x63,
        0x1f, 0xfd, 0x84, 0xf6, 0x67, 0x32, 0xd3, 0x47,
        0x3f, 0xbd, 0x16, 0x27, 0xe6, 0x3d, 0xc7, 0x19,
        0x40, 0x48, 0xeb, 0xec, 0x93, 0xc9, 0x5c, 0x15,
        0x9b, 0x50, 0x39, 0xab, 0x5e, 0x79, 0xe4, 0x2c,
        0x80, 0xb4, 0x84, 0xa9, 0x43, 0xf1, 0x25, 0xde,
        0x3d, 0xa1, 0xe0, 0x4e, 0x5b, 0xf9, 0xc1, 0x66,
        0x71, 0xad, 0x55, 0xa1, 0x11, 0x7d, 0x33, 0x06
    };

    /* Private Key */
    const uint8_t priv_key[] = {
        0xb6, 0xfa, 0xf2, 0xc8, 0x92, 0x22, 0x35, 0xc5,
        0x89, 0xc2, 0x73, 0x68, 0xa3, 0xb3, 0xe6, 0xe2,
        0xf4, 0x2e, 0xb6, 0x07, 0x3b, 0xf9, 0x50, 0x7f,
        0x19, 0xee, 0xd0, 0x74, 0x6c, 0x79, 0xdc, 0xed
    };

    /* Public Key */
    const uint8_t public_key[] = {
        0xe0, 0xe7, 0xb9, 0x9b, 0xc6, 0x2d, 0x8d, 0xd6,
        0x78, 0x83, 0xe3, 0x9e, 0xd9, 0xfa, 0x06, 0x57,
        0x78, 0x9c, 0x5f, 0xf5, 0x56, 0xcc, 0x1f, 0xd8,
        0xdd, 0x1e, 0x2a, 0x55, 0xe9, 0xe3, 0xf2, 0x43,
        0x63, 0xfb, 0xfd, 0x02, 0x32, 0xb9, 0x55, 0x78,
        0x07, 0x5c, 0x90, 0x3a, 0x4d, 0xbf, 0x85, 0xad,
        0x58, 0xf8, 0x35, 0x05, 0x16, 0xe1, 0xec, 0x89,
        0xb0, 0xee, 0x1f, 0x5e, 0x13, 0x62, 0xda, 0x69
    };

    /* Expected signature*/
    const uint8_t expected_signature[] = {
        0xf5, 0x08, 0x78, 0x78, 0xe2, 0x12, 0xb7, 0x03,
        0x57, 0x8f, 0x5c, 0x66, 0xf4, 0x34, 0x88, 0x3f,
        0x3e, 0xf4, 0x14, 0xdc, 0x23, 0xe2, 0xe8, 0xd8,
        0xab, 0x6a, 0x8d, 0x15, 0x9e, 0xd5, 0xad, 0x83,
        0x30, 0x6b, 0x4c, 0x6c, 0x20, 0x21, 0x37, 0x07,
        0x98, 0x2d, 0xff, 0xbb, 0x30, 0xfb, 0xa9, 0x9b,
        0x96, 0xe7, 0x92, 0x16, 0x3d, 0xd5, 0x9d, 0xbe,
        0x60, 0x6e, 0x73, 0x43, 0x28, 0xdd, 0x7c, 0x8a
    };
#elif LIBSPDM_SHA256_SUPPORT
    hash_nid = LIBSPDM_CRYPTO_NID_SHA256;

    /* The message to sign. */
    const uint8_t message[] = {
        0x59, 0x05, 0x23, 0x88, 0x77, 0xc7, 0x74, 0x21,
        0xf7, 0x3e, 0x43, 0xee, 0x3d, 0xa6, 0xf2, 0xd9,
        0xe2, 0xcc, 0xad, 0x5f, 0xc9, 0x42, 0xdc, 0xec,
        0x0c, 0xbd, 0x25, 0x48, 0x29, 0x35, 0xfa, 0xaf,
        0x41, 0x69, 0x83, 0xfe, 0x16, 0x5b, 0x1a, 0x04,
        0x5e, 0xe2, 0xbc, 0xd2, 0xe6, 0xdc, 0xa3, 0xbd,
        0xf4, 0x6c, 0x43, 0x10, 0xa7, 0x46, 0x1f, 0x9a,
        0x37, 0x96, 0x0c, 0xa6, 0x72, 0xd3, 0xfe, 0xb5,
        0x47, 0x3e, 0x25, 0x36, 0x05, 0xfb, 0x1d, 0xdf,
        0xd2, 0x80, 0x65, 0xb5, 0x3c, 0xb5, 0x85, 0x8a,
        0x8a, 0xd2, 0x81, 0x75, 0xbf, 0x9b, 0xd3, 0x86,
        0xa5, 0xe4, 0x71, 0xea, 0x7a, 0x65, 0xc1, 0x7c,
        0xc9, 0x34, 0xa9, 0xd7, 0x91, 0xe9, 0x14, 0x91,
        0xeb, 0x37, 0x54, 0xd0, 0x37, 0x99, 0x79, 0x0f,
        0xe2, 0xd3, 0x08, 0xd1, 0x61, 0x46, 0xd5, 0xc9,
        0xb0, 0xd0, 0xde, 0xbd, 0x97, 0xd7, 0x9c, 0xe8
    };

    /* Private Key */
    const uint8_t priv_key[] = {
        0x51, 0x9b, 0x42, 0x3d, 0x71, 0x5f, 0x8b, 0x58,
        0x1f, 0x4f, 0xa8, 0xee, 0x59, 0xf4, 0x77, 0x1a,
        0x5b, 0x44, 0xc8, 0x13, 0x0b, 0x4e, 0x3e, 0xac,
        0xca, 0x54, 0xa5, 0x6d, 0xda, 0x72, 0xb4, 0x64
    };

    /* Public Key */
    const uint8_t public_key[] = {
        0x1c, 0xcb, 0xe9, 0x1c, 0x07, 0x5f, 0xc7, 0xf4,
        0xf0, 0x33, 0xbf, 0xa2, 0x48, 0xdb, 0x8f, 0xcc,
        0xd3, 0x56, 0x5d, 0xe9, 0x4b, 0xbf, 0xb1, 0x2f,
        0x3c, 0x59, 0xff, 0x46, 0xc2, 0x71, 0xbf, 0x83,
        0xce, 0x40, 0x14, 0xc6, 0x88, 0x11, 0xf9, 0xa2,
        0x1a, 0x1f, 0xdb, 0x2c, 0x0e, 0x61, 0x13, 0xe0,
        0x6d, 0xb7, 0xca, 0x93, 0xb7, 0x40, 0x4e, 0x78,
        0xdc, 0x7c, 0xcd, 0x5c, 0xa8, 0x9a, 0x4c, 0xa9
    };

    /* Expected signature*/
    const uint8_t expected_signature[] = {
        0xf3, 0xac, 0x80, 0x61, 0xb5, 0x14, 0x79, 0x5b,
        0x88, 0x43, 0xe3, 0xd6, 0x62, 0x95, 0x27, 0xed,
        0x2a, 0xfd, 0x6b, 0x1f, 0x6a, 0x55, 0x5a, 0x7a,
        0xca, 0xbb, 0x5e, 0x6f, 0x79, 0xc8, 0xc2, 0xac,
        0x8b, 0xf7, 0x78, 0x19, 0xca, 0x05, 0xa6, 0xb2,
        0x78, 0x6c, 0x76, 0x26, 0x2b, 0xf7, 0x37, 0x1c,
        0xef, 0x97, 0xb2, 0x18, 0xe9, 0x6f, 0x17, 0x5a,
        0x3c, 0xcd, 0xda, 0x2a, 0xcc, 0x05, 0x89, 0x03
    };
#endif

    ec_context = libspdm_ec_new_by_nid(LIBSPDM_CRYPTO_NID_ECDSA_NIST_P256);
    if (ec_context == NULL) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "ec_context new failed \n"));
        result = false;
        goto update;
    }

    result = libspdm_ec_set_pub_key(ec_context, public_key, sizeof(public_key));
    if (!result) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "ec_context set pub_key failed \n"));
        libspdm_ec_free(ec_context);
        result = false;
        goto update;
    }

    result = libspdm_ec_set_priv_key(ec_context, priv_key, sizeof(priv_key));
    if (!result) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "ec_context set priv_key failed \n"));
        libspdm_ec_free(ec_context);
        result = false;
        goto update;
    }

    /*ECDSA KAT test*/
    result = libspdm_ecdsa_sign_fips(ec_context, hash_nid,
                                     message, sizeof(message),
                                     signature, &sig_size,
                                     libspdm_hardcode_random_number_ecdsa);
    if (!result) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "ECDSA sign failed \n"));
        libspdm_ec_free(ec_context);
        result = false;
        goto update;
    }

    if (sig_size != sizeof(expected_signature)) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "ECDSA KAT failed \n"));
        libspdm_ec_free(ec_context);
        result = false;
        goto update;
    }

    if (!libspdm_consttime_is_mem_equal(signature, expected_signature,
                                        sizeof(expected_signature))) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "ECDSA KAT failed \n"));
        libspdm_ec_free(ec_context);
        result = false;
        goto update;
    }

    result = libspdm_ecdsa_verify_fips(ec_context, hash_nid,
                                       message, sizeof(message),
                                       signature, sig_size);
    if (!result) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "ECDSA selftest failed \n"));
        libspdm_ec_free(ec_context);
        result = false;
        goto update;
    }

    libspdm_ec_free(ec_context);

update:
    /* mark it as tested*/
    context->tested_algo |= LIBSPDM_FIPS_SELF_TEST_ECDSA;

    /* record test result*/
    if (result) {
        context->self_test_result |= LIBSPDM_FIPS_SELF_TEST_ECDSA;
    } else {
        context->self_test_result &= ~LIBSPDM_FIPS_SELF_TEST_ECDSA;
    }

#endif/*(LIBSPDM_ECDSA_SUPPORT) && (LIBSPDM_SHA2_SUPPORT)*/
}

#endif/*LIBSPDM_FIPS_MODE*/
