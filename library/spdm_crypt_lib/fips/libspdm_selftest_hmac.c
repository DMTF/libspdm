/**
 *  Copyright Notice:
 *  Copyright 2023-2026 DMTF. All rights reserved.
 *  License: BSD 3-Clause License. For full text see link: https://github.com/DMTF/libspdm/blob/main/LICENSE.md
 **/

#include "internal/libspdm_crypt_lib.h"
#include "internal/libspdm_common_lib.h"
#include "internal/libspdm_fips_lib.h"

#if LIBSPDM_FIPS_MODE

void libspdm_fips_selftest_hmac_sha256(void *fips_selftest_context)
{
#if LIBSPDM_SHA256_SUPPORT
    bool result = true;

    libspdm_fips_selftest_context_t *context = fips_selftest_context;
    LIBSPDM_ASSERT(fips_selftest_context != NULL);

    /* any test fail cause the FIPS fail*/
    if (context->tested_algo != context->self_test_result) {
        return;
    }

    /* check if run before.*/
    if ((context->tested_algo & LIBSPDM_FIPS_SELF_TEST_HMAC_SHA256) != 0) {
        return;
    }

    /* Test vector (key, msg and mac) from the NIST CAVP: HMAC.rsp, [L=32], Count = 30.
     * https://csrc.nist.gov/projects/cryptographic-algorithm-validation-program/message-authentication
     */
    const uint8_t key[] = {
        0x97, 0x79, 0xd9, 0x12, 0x06, 0x42, 0x79, 0x7f,
        0x17, 0x47, 0x02, 0x5d, 0x5b, 0x22, 0xb7, 0xac,
        0x60, 0x7c, 0xab, 0x08, 0xe1, 0x75, 0x8f, 0x2f,
        0x3a, 0x46, 0xc8, 0xbe, 0x1e, 0x25, 0xc5, 0x3b,
        0x8c, 0x6a, 0x8f, 0x58, 0xff, 0xef, 0xa1, 0x76
    };
    const uint8_t msg[] = {
        0xb1, 0x68, 0x9c, 0x25, 0x91, 0xea, 0xf3, 0xc9,
        0xe6, 0x60, 0x70, 0xf8, 0xa7, 0x79, 0x54, 0xff,
        0xb8, 0x17, 0x49, 0xf1, 0xb0, 0x03, 0x46, 0xf9,
        0xdf, 0xe0, 0xb2, 0xee, 0x90, 0x5d, 0xcc, 0x28,
        0x8b, 0xaf, 0x4a, 0x92, 0xde, 0x3f, 0x40, 0x01,
        0xdd, 0x9f, 0x44, 0xc4, 0x68, 0xc3, 0xd0, 0x7d,
        0x6c, 0x6e, 0xe8, 0x2f, 0xac, 0xea, 0xfc, 0x97,
        0xc2, 0xfc, 0x0f, 0xc0, 0x60, 0x17, 0x19, 0xd2,
        0xdc, 0xd0, 0xaa, 0x2a, 0xec, 0x92, 0xd1, 0xb0,
        0xae, 0x93, 0x3c, 0x65, 0xeb, 0x06, 0xa0, 0x3c,
        0x9c, 0x93, 0x5c, 0x2b, 0xad, 0x04, 0x59, 0x81,
        0x02, 0x41, 0x34, 0x7a, 0xb8, 0x7e, 0x9f, 0x11,
        0xad, 0xb3, 0x04, 0x15, 0x42, 0x4c, 0x6c, 0x7f,
        0x5f, 0x22, 0xa0, 0x03, 0xb8, 0xab, 0x8d, 0xe5,
        0x4f, 0x6d, 0xed, 0x0e, 0x3a, 0xb9, 0x24, 0x5f,
        0xa7, 0x95, 0x68, 0x45, 0x1d, 0xfa, 0x25, 0x8e
    };

    uint8_t hmac_256_result[32];
    const uint8_t hmac_sha256_answer[] = {
        0x76, 0x9f, 0x00, 0xd3, 0xe6, 0xa6, 0xcc, 0x1f,
        0xb4, 0x26, 0xa1, 0x4a, 0x4f, 0x76, 0xc6, 0x46,
        0x2e, 0x61, 0x49, 0x72, 0x6e, 0x0d, 0xee, 0x0e,
        0xc0, 0xcf, 0x97, 0xa1, 0x66, 0x05, 0xac, 0x8b
    };
    libspdm_zero_mem(hmac_256_result, sizeof(hmac_256_result));
    result = libspdm_hmac_sha256_all(msg, sizeof(msg), key, sizeof(key), hmac_256_result);
    if (!result) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "gen hmac_sha256 failed \n"));
        goto update;
    }

    if (!libspdm_consttime_is_mem_equal(hmac_256_result, hmac_sha256_answer,
                                        sizeof(hmac_sha256_answer))) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "hmac_sha256 KAT failed \n"));
        result = false;
        goto update;
    }

update:
    /* mark it as tested*/
    context->tested_algo |= LIBSPDM_FIPS_SELF_TEST_HMAC_SHA256;

    /* record test result*/
    if (result) {
        context->self_test_result |= LIBSPDM_FIPS_SELF_TEST_HMAC_SHA256;
    } else {
        context->self_test_result &= ~LIBSPDM_FIPS_SELF_TEST_HMAC_SHA256;
    }

#endif/*LIBSPDM_SHA256_SUPPORT*/
}

void libspdm_fips_selftest_hmac_sha384(void *fips_selftest_context)
{
#if LIBSPDM_SHA384_SUPPORT
    bool result = true;

    libspdm_fips_selftest_context_t *context = fips_selftest_context;
    LIBSPDM_ASSERT(fips_selftest_context != NULL);

    /* any test fail cause the FIPS fail*/
    if (context->tested_algo != context->self_test_result) {
        return;
    }

    /* check if run before.*/
    if ((context->tested_algo & LIBSPDM_FIPS_SELF_TEST_HMAC_SHA384) != 0) {
        return;
    }

    /* Test vector (key, msg and mac) from the NIST CAVP: HMAC.rsp, [L=48], Count = 45.
     * https://csrc.nist.gov/projects/cryptographic-algorithm-validation-program/message-authentication
     */
    const uint8_t key[] = {
        0x5e, 0xab, 0x0d, 0xfa, 0x27, 0x31, 0x12, 0x60,
        0xd7, 0xbd, 0xdc, 0xf7, 0x71, 0x12, 0xb2, 0x3d,
        0x8b, 0x42, 0xeb, 0x7a, 0x5d, 0x72, 0xa5, 0xa3,
        0x18, 0xe1, 0xba, 0x7e, 0x79, 0x27, 0xf0, 0x07,
        0x9d, 0xbb, 0x70, 0x13, 0x17, 0xb8, 0x7a, 0x33,
        0x40, 0xe1, 0x56, 0xdb, 0xce, 0xe2, 0x8e, 0xc3,
        0xa8, 0xd9
    };
    const uint8_t msg[] = {
        0xf4, 0x13, 0x80, 0x12, 0x3c, 0xcb, 0xec, 0x4c,
        0x52, 0x7b, 0x42, 0x56, 0x52, 0x64, 0x11, 0x91,
        0xe9, 0x0a, 0x17, 0xd4, 0x5e, 0x2f, 0x62, 0x06,
        0xcf, 0x01, 0xb5, 0xed, 0xbe, 0x93, 0x2d, 0x41,
        0xcc, 0x8a, 0x24, 0x05, 0xc3, 0x19, 0x56, 0x17,
        0xda, 0x2f, 0x42, 0x05, 0x35, 0xee, 0xd4, 0x22,
        0xac, 0x60, 0x40, 0xd9, 0xcd, 0x65, 0x31, 0x42,
        0x24, 0xf0, 0x23, 0xf3, 0xba, 0x73, 0x0d, 0x19,
        0xdb, 0x98, 0x44, 0xc7, 0x1c, 0x32, 0x9c, 0x8d,
        0x9d, 0x73, 0xd0, 0x4d, 0x8c, 0x5f, 0x24, 0x4a,
        0xea, 0x80, 0x48, 0x82, 0x92, 0xdc, 0x80, 0x3e,
        0x77, 0x24, 0x02, 0xe7, 0x2d, 0x2e, 0x9f, 0x1b,
        0xab, 0xa5, 0xa6, 0x00, 0x4f, 0x00, 0x06, 0xd8,
        0x22, 0xb0, 0xb2, 0xd6, 0x5e, 0x9e, 0x4a, 0x30,
        0x2d, 0xd4, 0xf7, 0x76, 0xb4, 0x7a, 0x97, 0x22,
        0x50, 0x05, 0x1a, 0x70, 0x1f, 0xab, 0x2b, 0x70
    };

    uint8_t hmac_384_result[48];
    const uint8_t hmac_sha384_answer[] = {
        0x7c, 0xf5, 0xa0, 0x61, 0x56, 0xad, 0x3d, 0xe5,
        0x40, 0x5a, 0x5d, 0x26, 0x1d, 0xe9, 0x02, 0x75,
        0xf9, 0xbb, 0x36, 0xde, 0x45, 0x66, 0x7f, 0x84,
        0xd0, 0x8f, 0xbc, 0xb3, 0x08, 0xca, 0x8f, 0x53,
        0xa4, 0x19, 0xb0, 0x7d, 0xea, 0xb3, 0xb5, 0xf8,
        0xea, 0x23, 0x1c, 0x5b, 0x03, 0x6f, 0x88, 0x75
    };
    libspdm_zero_mem(hmac_384_result, sizeof(hmac_384_result));
    result = libspdm_hmac_sha384_all(msg, sizeof(msg), key, sizeof(key), hmac_384_result);
    if (!result) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "gen hmac_sha384 failed \n"));
        goto update;
    }

    if (!libspdm_consttime_is_mem_equal(hmac_384_result, hmac_sha384_answer,
                                        sizeof(hmac_sha384_answer))) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "hmac_sha384 KAT failed \n"));
        result = false;
        goto update;
    }

update:
    /* mark it as tested*/
    context->tested_algo |= LIBSPDM_FIPS_SELF_TEST_HMAC_SHA384;

    /* record test result*/
    if (result) {
        context->self_test_result |= LIBSPDM_FIPS_SELF_TEST_HMAC_SHA384;
    } else {
        context->self_test_result &= ~LIBSPDM_FIPS_SELF_TEST_HMAC_SHA384;
    }

#endif/*LIBSPDM_SHA384_SUPPORT*/
}

void libspdm_fips_selftest_hmac_sha512(void *fips_selftest_context)
{
#if LIBSPDM_SHA512_SUPPORT
    bool result = true;

    libspdm_fips_selftest_context_t *context = fips_selftest_context;
    LIBSPDM_ASSERT(fips_selftest_context != NULL);

    /* any test fail cause the FIPS fail*/
    if (context->tested_algo != context->self_test_result) {
        return;
    }

    /* check if run before.*/
    if ((context->tested_algo & LIBSPDM_FIPS_SELF_TEST_HMAC_SHA512) != 0) {
        return;
    }

    /* Test vector (key, msg and mac) from the NIST CAVP: HMAC.rsp, [L=64], Count = 60.
     * https://csrc.nist.gov/projects/cryptographic-algorithm-validation-program/message-authentication
     */
    const uint8_t key[] = {
        0x57, 0xc2, 0xeb, 0x67, 0x7b, 0x50, 0x93, 0xb9,
        0xe8, 0x29, 0xea, 0x4b, 0xab, 0xb5, 0x0b, 0xde,
        0x55, 0xd0, 0xad, 0x59, 0xfe, 0xc3, 0x4a, 0x61,
        0x89, 0x73, 0x80, 0x2b, 0x2a, 0xd9, 0xb7, 0x8e,
        0x26, 0xb2, 0x04, 0x5d, 0xda, 0x78, 0x4d, 0xf3,
        0xff, 0x90, 0xae, 0x0f, 0x2c, 0xc5, 0x1c, 0xe3,
        0x9c, 0xf5, 0x48, 0x67, 0x32, 0x0a, 0xc6, 0xf3,
        0xba, 0x2c, 0x6f, 0x0d, 0x72, 0x36, 0x04, 0x80,
        0xc9, 0x66, 0x14, 0xae, 0x66, 0x58, 0x1f, 0x26,
        0x6c, 0x35, 0xfb, 0x79, 0xfd, 0x28, 0x77, 0x4a,
        0xfd, 0x11, 0x3f, 0xa5, 0x18, 0x7e, 0xff, 0x92,
        0x06, 0xd7, 0xcb, 0xe9, 0x0d, 0xd8, 0xbf, 0x67,
        0xc8, 0x44, 0xe2, 0x02
    };
    const uint8_t msg[] = {
        0x24, 0x23, 0xdf, 0xf4, 0x8b, 0x31, 0x2b, 0xe8,
        0x64, 0xcb, 0x34, 0x90, 0x64, 0x1f, 0x79, 0x3d,
        0x2b, 0x9f, 0xb6, 0x8a, 0x77, 0x63, 0xb8, 0xe2,
        0x98, 0xc8, 0x6f, 0x42, 0x24, 0x5e, 0x45, 0x40,
        0xeb, 0x01, 0xae, 0x4d, 0x2d, 0x45, 0x00, 0x37,
        0x0b, 0x18, 0x86, 0xf2, 0x3c, 0xa2, 0xcf, 0x97,
        0x01, 0x70, 0x4c, 0xad, 0x5b, 0xd2, 0x1b, 0xa8,
        0x7b, 0x81, 0x1d, 0xaf, 0x7a, 0x85, 0x4e, 0xa2,
        0x4a, 0x56, 0x56, 0x5c, 0xed, 0x42, 0x5b, 0x35,
        0xe4, 0x0e, 0x1a, 0xcb, 0xeb, 0xe0, 0x36, 0x03,
        0xe3, 0x5d, 0xcf, 0x4a, 0x10, 0x0e, 0x57, 0x21,
        0x84, 0x08, 0xa1, 0xd8, 0xdb, 0xcc, 0x3b, 0x99,
        0x29, 0x6c, 0xfe, 0xa9, 0x31, 0xef, 0xe3, 0xeb,
        0xd8, 0xf7, 0x19, 0xa6, 0xd9, 0xa1, 0x54, 0x87,
        0xb9, 0xad, 0x67, 0xea, 0xfe, 0xdf, 0x15, 0x55,
        0x9c, 0xa4, 0x24, 0x45, 0xb0, 0xf9, 0xb4, 0x2e
    };

    uint8_t hmac_512_result[64];
    const uint8_t hmac_sha512_answer[] = {
        0x33, 0xc5, 0x11, 0xe9, 0xbc, 0x23, 0x07, 0xc6,
        0x27, 0x58, 0xdf, 0x61, 0x12, 0x5a, 0x98, 0x0e,
        0xe6, 0x4c, 0xef, 0xeb, 0xd9, 0x09, 0x31, 0xcb,
        0x91, 0xc1, 0x37, 0x42, 0xd4, 0x71, 0x4c, 0x06,
        0xde, 0x40, 0x03, 0xfa, 0xf3, 0xc4, 0x1c, 0x06,
        0xae, 0xfc, 0x63, 0x8a, 0xd4, 0x7b, 0x21, 0x90,
        0x6e, 0x6b, 0x10, 0x48, 0x16, 0xb7, 0x2d, 0xe6,
        0x26, 0x9e, 0x04, 0x5a, 0x1f, 0x44, 0x29, 0xd4
    };
    libspdm_zero_mem(hmac_512_result, sizeof(hmac_512_result));
    result = libspdm_hmac_sha512_all(msg, sizeof(msg), key, sizeof(key), hmac_512_result);
    if (!result) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "gen hmac_sha512 failed \n"));
        goto update;
    }

    if (!libspdm_consttime_is_mem_equal(hmac_512_result, hmac_sha512_answer,
                                        sizeof(hmac_sha512_answer))) {
        LIBSPDM_DEBUG((LIBSPDM_DEBUG_INFO, "hmac_sha512 KAT failed \n"));
        result = false;
        goto update;
    }
update:
    /* mark it as tested*/
    context->tested_algo |= LIBSPDM_FIPS_SELF_TEST_HMAC_SHA512;

    /* record test result*/
    if (result) {
        context->self_test_result |= LIBSPDM_FIPS_SELF_TEST_HMAC_SHA512;
    } else {
        context->self_test_result &= ~LIBSPDM_FIPS_SELF_TEST_HMAC_SHA512;
    }

#endif/*LIBSPDM_SHA512_SUPPORT*/
}

#endif/*LIBSPDM_FIPS_MODE*/
